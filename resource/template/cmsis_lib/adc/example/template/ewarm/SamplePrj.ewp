# IAR project SamplePrj.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\..\..\..\lib\cmsis_core\; ..\..\..\..\lib\cmsis_boot\; ..\..\..\..\lib\include\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: SamplePrj.out
  ILINK.IlinkIcfFile: E:\cox_export\Holtek\HT32F1755_2755\cmsis_lib\lib\cmsis_boot\startup\iar\ht32f175x_275x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\lib\cmsis_core\; ..\..\..\..\lib\cmsis_boot\; ..\..\..\..\lib\Include\
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: E:\manufactory_lib_holtek\Holtek\HT32F175x_275x\cmsis_lib\cmsis_boot\example\startup_test\ewarm\ht32f175x_275x_flash.icf
  group cmsis_boot
    ../../../../lib/cmsis_boot/: $series$.h system_$series$.c system_$series$.h
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c core_cm3.h
  group cmsis_lib/include
    ../../../../lib/include/: readme.txt
  group cmsis_lib/source
    ../../../../lib/src/: readme.txt
  group ewarm/startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_$series$.s
  group user
    ../src/: main.c template.c
