# Keil uVision project SamplePrj.uvproj, settings and files
target HT32F1755_2755_DVB (ARM-ADS)
  device: HT32F1755 Holtek
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SamplePrj
  c flags: Optim=1
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x8000
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_ht32f175x_275x.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_ht32f175x_275x.c
  group include
    ../../../../lib/include/: ht32f175x_275x_usart.h ht32f175x_275x_adc.h ht32f175x_275x_ckcu.h ht32f175x_275x_gpio.h ht32f175x_275x_rstcu.h
  group source
    ../../../../lib/src/: ht32f175x_275x_usart.c ht32f175x_275x_adc.c ht32f175x_275x_ckcu.c ht32f175x_275x_gpio.c ht32f175x_275x_rstcu.c
  group user
    ../src/: main.c potentiometer.c holtek_retarget.c
