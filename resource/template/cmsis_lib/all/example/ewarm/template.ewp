# IAR project template.ewp, settings and files
configuration Debug_Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: NUC140xE Nuvoton NUC140xE
  ICCARM.CCDefines: ewarm
  ICCARM.CCIncludePath2: ..\..\..\lib\include; ..\..\..\lib\cmsis_core; ..\..\..\lib\cmsis_boot\startup\iar; ..\..\..\lib\cmsis_boot
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Ram (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\lib\Include; ..\..\..\..\lib\Include\Driver; ..\..\..\..\lib\Include\System; ..\..\..\..\lib\cmsis_boot; ..\..\..\..\lib\cmsis_core
  OBJCOPY.OOCOutputFile: sample_sys.srec
  ILINK.IlinkIcfFile: nuc1xx_ram.icf
  group cmsis_boot
    ../../../lib/cmsis_boot/: $series$.h system_$series$.c system_$series$.h
  group cmsis_core
    ../../../lib/cmsis_core/: core_cm3.c core_cm3.h
  group cmsis_lib/include
    ../../../lib/include/: readme.txt
  group cmsis_lib/source
    ../../../lib/src/: readme.txt
  group ewarm
    ../../../lib/cmsis_boot/startup/iar/: startup_$series$.s
  group Source
    ../src/: main.c
