# Keil uVision project SamplePrj.uvproj, settings and files
target DMAC_UART_DEMO (ARM-ADS)
  device: TMPM366FDFG Toshiba
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x07FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SamplePrj
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include;..\..\..\..\lib\cmsis_boot\utilities
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\tmpm366.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM366.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM366.c
  group source
    ../../../../lib/source/: tmpm366_gpio.c tmpm366_dmac.c tmpm366_uart.c
  group user
    ../src/: main.c DMAC_UART_DEMO.c
