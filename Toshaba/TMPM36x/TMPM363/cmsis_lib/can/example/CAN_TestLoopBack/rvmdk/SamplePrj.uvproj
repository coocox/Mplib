# Keil uVision project SamplePrj.uvproj, settings and files
target CAN_TestLoopBack (ARM-ADS)
  device: TMPM363F10FG Toshiba
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x0FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SamplePrj
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include;..\..\..\..\lib\cmsis_boot\utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\tmpm363.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM363.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM363.c
  group source
    ../../../../lib/source/: tmpm363_adc.c tmpm363_can.c tmpm363_gpio.c
  group user
    ../src/: main.c CAN_TestLoopBack.c
