# Keil uVision project SamplePrj.uvproj, settings and files
target RTC_Basic (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SamplePrj
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include;..\..\..\..\lib\cmsis_boot\utilities
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\tmpm364.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM364.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM364.c
  group source
    ../../../../lib/source/: tmpm364_rtc.c tmpm364_uart.c
  group user
    ../src/: main.c RTC_Basic.c
