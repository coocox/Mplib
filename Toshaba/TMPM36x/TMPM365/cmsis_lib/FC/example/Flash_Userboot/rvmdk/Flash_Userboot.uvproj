# Keil uVision project Flash_Userboot.uvproj, settings and files
target Flash_Userboot (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CAN_TestLoopBack
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include
  scatter file: .\FlashSwap.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM365.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM365.c
  group source
    ../../../../lib/source/: tmpm365_gpio.c tmpm365_fc.c
  group user
    ../src/: main.c Flash_Userboot.c
