# Keil uVision project ADC_Data_Read.uvproj, settings and files
target DMAC_UART_DEMO (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CAN_TestLoopBack
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include
  scatter file: .\tmpm365.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM365.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM365.c
  group source
    ../../../../lib/source/: tmpm365_gpio.c tmpm365_uart.c tmpm365_dmac.c
  group user
    ../src/: main.c DMAC_UART_DEMO.c
