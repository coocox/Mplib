# IAR project SamplePrj.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HT32F125X_DRIVER; USE_HT32F1253_DVB
  ICCARM.CCIncludePath2: ..\..\..\..\lib\cmsis_boot; ..\..\..\..\lib\cmsis_core; ..\..\..\..\lib\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SamplePrj.srec
  ILINK.IlinkOutputFile: SamplePrj.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\lib\cmsis_core\; ..\..\..\..\lib\cmsis_boot\; ..\..\..\..\lib\Include\
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: E:\manufactory_lib_holtek\Holtek\HT32F175x_275x\cmsis_lib\cmsis_boot\example\startup_test\ewarm\ht32f175x_275x_flash.icf
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM365.c system_TMPM365.h TMPM365.h
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c core_cm3.h
  group cmsis_lib/include
    ../../../../lib/include/: tmpm365_dmac.h tmpm365_gpio.h tmpm365_uart.h
  group cmsis_lib/source
    ../../../../lib/source/: tmpm365_dmac.c tmpm365_gpio.c tmpm365_uart.c
  group ewarm/startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_TMPM365.s
  group user
    ../src/: DMAC_UART_DEMO.c main.c
