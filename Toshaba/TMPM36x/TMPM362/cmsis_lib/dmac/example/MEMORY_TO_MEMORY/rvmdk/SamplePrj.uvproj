# Keil uVision project SamplePrj.uvproj, settings and files
target MEMORY_TO_MEMORY (ARM-ADS)
  device: TMPM362F10FG Toshiba
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x0FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SamplePrj
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include;..\..\..\..\lib\cmsis_boot\utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\tmpm362.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM362.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM362.c
  group source
    ../../../../lib/source/: tmpm362_uart.c tmpm362_dmac.c
  group user
    ../src/: main.c MEMORY_TO_MEMORY.c
