# Keil uVision project uDMAC_Demo.uvproj, settings and files
target uDMAC_Demo (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: uDMAC_Demo
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\include;..\..\..\..\lib\cmsis_core
  scatter file: .\tmpm369.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM369.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM369.c
  group source
    ../../../../lib/source/: tmpm369_udmac.c tmpm369_gpio.c tmpm369_uart.c
  group user
    ../src/: main.c uDMAC_Demo.c
