# Keil uVision project CAN_TestLoopBack.uvproj, settings and files
target CAN_TestLoopBack (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: CAN_TestLoopBack
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include
  scatter file: .\tmpm369.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM369.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM369.c
  group source
    ../../../../lib/source/: tmpm369_adc.c tmpm369_can.c tmpm369_gpio.c tmpm369_uart.c
  group user
    ../src/: CAN_TsetLoopBack.c main.c
