# Keil uVision project FUART_LoopBack.uvproj, settings and files
target FUART_LoopBack (ARM-ADS)
  device: TMPM369FDXBG Toshiba
  cpu: IRAM(0x20000000-0x200007FF) IRAM2(0x20000800-0x2001FFFF) IROM(0-0x07FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: FUART_LoopBack
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\include;..\..\..\..\lib\cmsis_core
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x800
  memory RVCT10: RAM 0x20000800 size 0x1f800
  scatter file: .\tmpm369.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM369.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM369.c
  group source
    ../../../../lib/source/: tmpm369_fuart.c tmpm369_gpio.c
  group user
    ../src/: FUART_LoopBack.c main.c
