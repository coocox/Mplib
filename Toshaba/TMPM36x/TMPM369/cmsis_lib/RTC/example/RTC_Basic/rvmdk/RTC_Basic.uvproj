# Keil uVision project RTC_Basic.uvproj, settings and files
target RTC_Basic (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: RTC_Basic
  c include: ..\..\..\..\lib\cmsis_core;..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\include
  scatter file: .\tmpm369.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM369.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM369.c
  group source
    ../../../../lib/source/: tmpm369_cg.c tmpm369_gpio.c tmpm369_rtc.c tmpm369_uart.c
  group user
    ../src/: main.c RTC_Basic.c
