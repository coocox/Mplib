# Keil uVision project SamplePrj.uvproj, settings and files
target ADC_Data_Read (ARM-ADS)
  device: TMPM333FDFG Toshiba
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: SamplePrj
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include;..\..\..\..\lib\cmsis_boot\utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\tmpm333.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM333.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM333.c
  group source
    ../../../../lib/source/: tmpm333_adc.c tmpm333_uart.c
  group user
    ../src/: main.c ADC_Data_Read.c
