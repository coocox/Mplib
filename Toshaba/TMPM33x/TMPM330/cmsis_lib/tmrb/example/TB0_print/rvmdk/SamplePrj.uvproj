# Keil uVision project SamplePrj.uvproj, settings and files
target TB0_print (ARM-ADS)
  device: TMPM330FDFG Toshiba
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SamplePrj
  c include: ..\..\..\..\lib\cmsis_boot;..\..\..\..\lib\cmsis_core;..\..\..\..\lib\include;..\..\..\..\lib\cmsis_boot\utilities
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\tmpm330.sct
  group rvmdk
    ../../../../lib/cmsis_boot/startup/arm/: startup_TMPM330.s
  group cmsis_core
    ../../../../lib/cmsis_core/: core_cm3.c
  group cmsis_boot
    ../../../../lib/cmsis_boot/: system_TMPM330.c
  group source
    ../../../../lib/source/: tmpm330_uart.c tmpm330_tmrb.c tmpm330_wdt.c
  group user
    ../src/: main.c TB0_print.c
