# IAR project templet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM370FYDFG Toshiba TMPM370FYDFG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\lib\inc; ..\..\..\..\lib\cmsis_boot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templet.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: cg.c cg.h Example_ModeSwitch.c led.c led.h main.c main.h sw.c sw.h tmpm370_int.c tmpm370_int.h
  group cmsis
    ../../../../lib/cmsis_boot/: system_TMPM370.c system_TMPM370.h TMPM370.h
  group driver/inc
    ../../../../lib/inc/: tmpm370_adc.h tmpm370_cg.h tmpm370_fc.h tmpm370_gpio.h tmpm370_ofd.h tmpm370_tmrb.h tmpm370_uart.h tmpm370_vltd.h tmpm370_wdt.h tx03_common.h
  group driver/src
    ../../../../lib/src/: tmpm370_adc.c tmpm370_cg.c tmpm370_fc.c tmpm370_gpio.c tmpm370_ofd.c tmpm370_tmrb.c tmpm370_uart.c tmpm370_vltd.c tmpm370_wdt.c
  group startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_TMPM370.s
