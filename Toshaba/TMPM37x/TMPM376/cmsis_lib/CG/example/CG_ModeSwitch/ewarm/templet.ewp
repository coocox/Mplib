# IAR project templet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM376FDDFG Toshiba TMPM376FDDFG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\lib\inc; ..\..\..\..\lib\cmsis_boot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templet.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: cg.c cg.h Example_CG_ModeSwitch.c led.c led.h main.c main.h sw.c sw.h tmpm376_int.c tmpm376_int.h
  group cmsis
    ../../../../lib/cmsis_boot/: system_TMPM376.c system_TMPM376.h TMPM376.h
  group driver/inc
    ../../../../lib/inc/: tmpm376_adc.h tmpm376_cg.h tmpm376_fc.h tmpm376_gpio.h tmpm376_ofd.h tmpm376_tmrb.h tmpm376_uart.h tmpm376_vltd.h tmpm376_wdt.h tx03_common.h
  group driver/src
    ../../../../lib/src/: tmpm376_adc.c tmpm376_cg.c tmpm376_fc.c tmpm376_gpio.c tmpm376_ofd.c tmpm376_tmrb.c tmpm376_uart.c tmpm376_vltd.c tmpm376_wdt.c
  group startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_TMPM376.s
