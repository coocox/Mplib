# IAR project templet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM374FWUG Toshiba TMPM374FWUG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\lib\inc; ..\..\..\..\lib\cmsis_boot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templet.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: cg.c cg.h Example_CG_ModeSwitch.c led.c led.h main.c main.h tmpm374_int.c tmpm374_int.h
  group cmsis
    ../../../../lib/cmsis_boot/: system_TMPM374.c system_TMPM374.h TMPM374.h
  group driver/inc
    ../../../../lib/inc/: tmpm374_adc.h tmpm374_cg.h tmpm374_fc.h tmpm374_gpio.h tmpm374_ofd.h tmpm374_tmrb.h tmpm374_uart.h tmpm374_vltd.h tmpm374_wdt.h tx03_common.h
  group driver/src
    ../../../../lib/src/: tmpm374_adc.c tmpm374_cg.c tmpm374_fc.c tmpm374_gpio.c tmpm374_ofd.c tmpm374_tmrb.c tmpm374_uart.c tmpm374_vltd.c tmpm374_wdt.c
  group startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_TMPM374.s
