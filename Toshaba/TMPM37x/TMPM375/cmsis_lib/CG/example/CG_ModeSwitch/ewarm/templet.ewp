# IAR project templet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM370FYDFG Toshiba TMPM370FYDFG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\lib\inc; ..\..\..\..\lib\cmsis_boot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templet.out
  ILINK.IlinkIcfFile: templet.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: cg.c cg.h common_uart.c common_uart.h Example_CG_ModeSwitch.c led.c led.h main.c main.h sw.c sw.h tmpm375_int.c tmpm375_int.h
  group cmsis
    ../../../../lib/cmsis_boot/: system_TMPM375.c system_TMPM375.h TMPM375.h
  group driver/inc
    ../../../../lib/inc/: tmpm375_adc.h tmpm375_cg.h tmpm375_enc.h tmpm375_fc.h tmpm375_gpio.h tmpm375_ofd.h tmpm375_sbi.h tmpm375_tmrb.h tmpm375_uart.h tmpm375_vltd.h tmpm375_wdt.h tx03_common.h
  group driver/src
    ../../../../lib/src/: tmpm375_adc.c tmpm375_cg.c tmpm375_enc.c tmpm375_fc.c tmpm375_gpio.c tmpm375_ofd.c tmpm375_sbi.c tmpm375_tmrb.c tmpm375_uart.c tmpm375_vltd.c tmpm375_wdt.c
  group startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_TMPM375.s
