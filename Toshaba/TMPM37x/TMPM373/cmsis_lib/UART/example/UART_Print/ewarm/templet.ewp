# IAR project templet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM373FWDUG Toshiba TMPM373FWDUG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\lib\inc; ..\..\..\..\lib\cmsis_boot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templet.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: Example_UART_Print.c main.c main.h tmpm373_uart_int.c tmpm373_uart_int.h uart.c uart.h
  group cmsis
    ../../../../lib/cmsis_boot/: system_TMPM373.c system_TMPM373.h TMPM373.h
  group driver/inc
    ../../../../lib/inc/: tmpm373_adc.h tmpm373_cg.h tmpm373_fc.h tmpm373_gpio.h tmpm373_ofd.h tmpm373_tmrb.h tmpm373_uart.h tmpm373_vltd.h tmpm373_wdt.h tx03_common.h
  group driver/src
    ../../../../lib/src/: tmpm373_adc.c tmpm373_cg.c tmpm373_fc.c tmpm373_gpio.c tmpm373_ofd.c tmpm373_tmrb.c tmpm373_uart.c tmpm373_vltd.c tmpm373_wdt.c
  group startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_TMPM373.s
