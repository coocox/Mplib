# IAR project templet.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPM372FWUG Toshiba TMPM372FWUG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\src; ..\..\..\..\lib\inc; ..\..\..\..\lib\cmsis_boot
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: templet.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../src/: Example_UART_Print.c main.c main.h tmpm372_uart_int.c tmpm372_uart_int.h uart.c uart.h
  group cmsis
    ../../../../lib/cmsis_boot/: system_TMPM372.c system_TMPM372.h TMPM372.h
  group driver/inc
    ../../../../lib/inc/: tmpm372_adc.h tmpm372_cg.h tmpm372_fc.h tmpm372_gpio.h tmpm372_ofd.h tmpm372_tmrb.h tmpm372_uart.h tmpm372_vltd.h tmpm372_wdt.h tx03_common.h
  group driver/src
    ../../../../lib/src/: tmpm372_adc.c tmpm372_cg.c tmpm372_fc.c tmpm372_gpio.c tmpm372_ofd.c tmpm372_tmrb.c tmpm372_uart.c tmpm372_vltd.c tmpm372_wdt.c
  group startup
    ../../../../lib/cmsis_boot/startup/iar/: startup_TMPM372.s
